# Keil uVision project Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\obj\1.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\T5L51
  group Source Group 1
    ./: main.c STARTUP_M5.A51 sys.c sys.h T5LOS8051.h uart.c uart.h
